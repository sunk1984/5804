# IAR project PowerPacMerak.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9260 Atmel AT91SAM9260
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=1; MERAK_DEBUG=0
  ICCARM.CCIncludePath2: common\BSP\; common\Driver\Comm485\; common\Driver\CommDUT\; common\Driver\USART\; common\Driver\ADC\; common\Driver\I2C\; common\Driver\ExtIO\; common\Driver\HMI\; common\Driver\LCD\; common\Driver\AUDIO\; common\Driver\relay\; common\Driver\ScanGun\; common\Driver\Power\; common\Driver\IP_PING\; common\FrameWork\; common\FrameWork\CfgFile\; common\FrameWork\LogFile\; common\FrameWork\InitFile\; common\FrameWork\Task\; common\FrameWork\TestLib\; common\PowerPac\RTOS\Inc\; common\PowerPac\FileSystem\Inc\; common\PowerPac\TCPIP\Inc\; common\PowerPac\USB\Inc\; common\PowerPac\USBH\Inc\; common\PowerPac\USBH_OLD\Inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PowerPacMerak.bin
  ILINK.IlinkOutputFile: PowerPacMerak.out
  ILINK.IlinkConfigDefines: DEBUG=1
  ILINK.IlinkIcfFile: cfg\AT91SAM9260-SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1
  OBJCOPY.OOCOutputFile: APP.bin
  ILINK.IlinkIcfFile: cfg\MERAK-WITH-BOOT-NORFLASH.icf
  group APP
    APP/: TestApp.c
  group cfg
    cfg/: AT91SAM9260-NORFLASH.icf AT91SAM9260-SDRAM.icf AT91SAM9260_SDRAM_IAR6.mac MERAK-WITH-BOOT-NORFLASH.icf path.txt
  group common/BSP
    Common/BSP/: BSP.c BSP.h cstartup.s ioat91sam9260.h
  group common/Driver/ADC
    Common/Driver/ADC/: MCP3421_ADC.c MCP3421_ADC.h
  group common/Driver/AUDIO
    Common/Driver/AUDIO/: audio.c Audio.h
  group common/Driver/Comm485
    Common/Driver/Comm485/: Comm_485.c Comm_485.h
  group common/Driver/CommDUT
    Common/Driver/CommDUT/: Comm_dut.c Comm_dut.h
  group common/Driver/ExtIO
    Common/Driver/ExtIO/: ExtIO_485.c ExtIO_485.h
  group common/Driver/HMI
    Common/Driver/HMI/: HMI_485.c HMI_485.h
  group common/Driver/I2C
    Common/Driver/I2C/: i2c_api.c i2c_api.h
  group common/Driver/IP_PING
    Common/Driver/IP_PING/: IP_Ping.c
  group common/Driver/LCD
    Common/Driver/LCD/: LCD.c LCD.h
  group common/Driver/Power
    Common/Driver/Power/: Power_485.c Power_485.h
  group common/Driver/Relay
    Common/Driver/Relay/: Relay.c Relay.h
  group common/Driver/ScanGun
    Common/Driver/ScanGun/: Scanner_USB.c Scanner_USB.h
  group common/Driver/USART
    Common/Driver/USART/: usart2.c usart2.h
  group common/FrameWork
    Common/FrameWork/: includes.h main.c type.h
  group common/FrameWork/CfgFile
    Common/FrameWork/CfgFile/: CfgFile.c CfgFile.h
  group common/FrameWork/InitFile
    Common/FrameWork/InitFile/: Calibrate.c InitFile.c InitFile.h
  group common/FrameWork/LogFile
    Common/FrameWork/LogFile/: LogFile.c LogFile.h
  group common/FrameWork/Task
    Common/FrameWork/Task/: Task.c Task.h
  group common/FrameWork/TestLib
    Common/FrameWork/TestLib/: TestLib.c TestLib.h
  group common/PowerPac/FileSystem
    Common/PowerPac/FileSystem/: fs5t_al__ds.a fs5t_al__rs.a FS_ConfigIO.c FS_ConfigNAND_x.c FS_NAND_HW_SAM9260.c FS_OS.c
  group common/PowerPac/RTOS
    Common/PowerPac/RTOS/: JLINKDCC_Process.c os5t_al__d.a os5t_al__r.a OS_Error.c RTOSInit_AT91SAM9260.c
  group common/PowerPac/TCPIP
    Common/PowerPac/TCPIP/: ip5t_al__d.a ip5t_al__r.a IP_Config_AT91SAM9260.c IP_ConfigIO.c IP_FS_FS.c IP_OS_embos.c
  group common/PowerPac/TCPIP/Inc
    Common/PowerPac/TCPIP/Inc/: FTPS_Conf.h Global.h IP.h IP_Conf.h IP_ConfDefaults.h IP_FS.h IP_FTPServer.h IP_Int.h IP_NI_AT91SAM9260.h IP_Q.h IP_SMTPC.h IP_socket.h IP_TFTP.h IP_UTIL.h IP_WebServer.h SEGGER.h SMTPC_Conf.h WEBS_Conf.h
  group common/PowerPac/USB
    Common/PowerPac/USB/: usb5t_al__d.a usb5t_al__r.a USB_Config_SAM9260.c USB_OS.c
  group common/PowerPac/USBH_OLD
    Common/PowerPac/USBH_OLD/: usbh5t_al__d.a usbh5t_al__r.a USBH_Conf.h USBH_Config_SAM9260.c USBH_ConfigIO.c USBH_OS.c
  group common/PowerPac/USBH_OLD/Inc
    Common/PowerPac/USBH_OLD/Inc/: USBH.h USBH_Conf.h USBH_ConfDefaults.h USBH_Int.h
  group common/PowerPac/USBH_OLD/USBD_core
    Common/PowerPac/USBH_OLD/Src/Core/: USBH_Core.c USBH_DebugStrings.c USBH_Device.c USBH_Driver.c USBH_EndPoint.c USBH_Enum.c USBH_HC.c USBH_HID.c USBH_Hub.c USBH_Interface.c USBH_InterfaceList.c USBH_Log.c USBH_MEM.c USBH_MSD.c USBH_MSD_FS.c USBH_MSD_PhysLayerSubclass05.c USBH_MSD_PhysLayerSubclass06.c USBH_MSD_PhysLayerWrapper.c USBH_OHC_Device.c USBH_OHC_EP.c USBH_OHC_EP_BulkInt.c USBH_OHC_EP_Control.c USBH_OHC_EP_Int.c USBH_OHC_HCCA.c USBH_OHC_RootHub.c USBH_OHC_td.c USBH_OHC_Transfer.c USBH_PnPNotification.c USBH_RootHub.c USBH_URB.c
